# Keil uVision project modbus_server.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ControlBox11
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: .\User;.\FreeRTOS\include;.\FreeRTOS\portable\GCC\ARM_CM3;.\HMAC-MD5;.\device;.\driver;C:\Users\45128\AppData\Local\Arm\Packs\GigaDevice\GD32F10x_DFP\2.0.3\Device\Include;C:\Users\45128\AppData\Local\Arm\Packs\ARM\CMSIS\5.9.0\CMSIS\Core\Include;C:\Users\45128\AppData\Local\Arm\Packs\GigaDevice\GD32F10x_DFP\2.0.3\Device\Firmware\Peripherals\inc;.\RTE\_Target_1;.\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group src
    ./User/: main.c crc.c utils.c AppConfig.c log.c modbus_s.c
  group bsp
    ./bsp/: systick.c Uart3.c Uart4.c Usart.c Usart0.c Usart1.c Usart2.c uTimer.c
  group include
    ./User/: APP.h crc.h utils.h AppConfig.h Log.h modbus_s.h
    ./bsp/: BitBandGPIO.h FreeRTOSConfig.h systick.h Usart.h uTimer.h
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/GCC/ARM_CM3/: port.c portmacro.h
    ./FreeRTOS/include/: FreeRTOS.h
  group HMAC-MD5
    ./HMAC-MD5/: hmac_md5.c hmac_md5.h md5.c md5.h
  group driver
    ./driver/: modbus.c modbus.h
software components: CMSIS:CORE 5.6.0, Device:GD32F10x_StdPeripherals:ADC 2.0.2, Device:GD32F10x_StdPeripherals:DAC 2.0.2, Device:GD32F10x_StdPeripherals:DMA 2.0.2, Device:GD32F10x_StdPeripherals:EXMC 2.0.2, Device:GD32F10x_StdPeripherals:EXTI 2.0.2, Device:GD32F10x_StdPeripherals:FMC 2.0.2, Device:GD32F10x_StdPeripherals:FWDGT 2.0.2, Device:GD32F10x_StdPeripherals:GPIO 2.0.2, Device:GD32F10x_StdPeripherals:I2C 2.0.2, Device:GD32F10x_StdPeripherals:MISC 2.0.2, Device:GD32F10x_StdPeripherals:PMU 2.0.2, Device:GD32F10x_StdPeripherals:RCU 2.0.2, Device:GD32F10x_StdPeripherals:TIMER 2.0.2, Device:GD32F10x_StdPeripherals:USART 2.0.2, Device:GD32F10x_libopt 2.0.2, Device:Startup 2.0.2
